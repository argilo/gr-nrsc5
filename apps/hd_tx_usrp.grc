options:
  parameters:
    generate_options: no_gui
    id: hd_tx_usrp
    output_language: python
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 87.5e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: sig
  id: variable
  parameters:
    value: '[0x40, 0x01, 0x00, 0x02, 0x69, 0x05, 0x00, 0x48, 0x44, 0x31, 0x66, 0x0c, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x5a, 0x6c, 0xc6, 0x4d, 0x67, 0x0d, 0x01, 0x00, 0x10, 0x09, 0x01, 0x03, 0x00, 0x00, 0x36, 0x75, 0x4b, 0xbe, 0x60, 0x09, 0x53, 0x45, 0x4c, 0x46, 0x28, 0x00, 0x00, 0x00, 0x67, 0x0d, 0x02, 0x01, 0x10, 0x09, 0x01, 0x03, 0x00, 0x00, 0x36, 0x25, 0xc7, 0xd9, 0x60, 0x09, 0x53, 0x45, 0x4c, 0x46, 0x32, 0x00, 0x00, 0x00]'
  states: {}
- name: analog_wfm_tx_0_0
  id: analog_wfm_tx
  parameters:
    audio_rate: audio_rate
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: audio_rate * 4
    tau: '75e-6'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: int(audio_rate * 3.5)
    type: float
  states: {}
- name: blocks_keep_m_in_n_0
  id: blocks_keep_m_in_n
  parameters:
    m: '2160'
    n: '4096'
    offset: '0'
    type: complex
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.cons(pmt.make_dict(), pmt.init_u8vector(5 + len(sig), [0x21, 0x20, 0x00, 0x00, 0x00] + sig))
    period: '1000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.001'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '2'
    type: complex
    vlen: '2048'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: '[math.sin(math.pi / 2 * i / 112) for i in range(112)] + [1] * (2048-112) + [math.cos(math.pi / 2 * i / 112) for i in range(112)]'
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '2048'
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: sample.wav
    nchan: '2'
    repeat: 'True'
  states: {}
- name: blocks_wavfile_source_1
  id: blocks_wavfile_source
  parameters:
    file: sample_mono.wav
    repeat: 'True'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      import struct
      import threading
      from gnuradio import gr


      class blk(gr.basic_block):
          """Read a file and encode it as LOT packets"""
          INTERVAL = 10.0

          def __init__(self, filename="", lot_id = 0, port=0):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='LOT encoder',
                  in_sig=[],
                  out_sig=[]
              )
              self.message_port_register_out(pmt.intern("aas"))

              self.filename = filename
              self.port = port
              self.lot_id = lot_id

          def start(self):
              self.parts = []
              with open(self.filename, "rb") as f:
                  data = f.read()
              
              for offset in range(0, len(data), 256):
                  chunk = data[offset:offset+256]
                  seq = offset // 256

                  if seq == 0:
                      header_len = 24 + len(self.filename.encode())
                  else:
                      header_len = 8
                  
                  repeat = 1
                  
                  header = struct.pack("<BBHI", header_len, repeat, self.lot_id, seq)
                  if seq == 0:
                      version = 1
                      expiry = 0x7eb4a59e
                      size = len(data)
                      mime = 0x4f328ca0  # PNG
                      header += struct.pack("<IIII", version, expiry, size, mime) + self.filename.encode()
                  
                  self.parts.append(header + chunk)
              
              self.aas_seq = 0
              self.timer = threading.Timer(self.INTERVAL, self.send)
              self.timer.start()
          
          def stop(self):
              self.timer.cancel()
              
          def send(self):
              print(f"Sending LOT file: {self.filename}")
              for part in self.parts:
                  aas_pdu = struct.pack("<BHH", 0x21, self.port, self.aas_seq) + part
                  msg = pmt.cons(pmt.make_dict(), pmt.init_u8vector(len(aas_pdu), list(aas_pdu)))
                  self.message_port_pub(pmt.intern("aas"), msg)
                  self.aas_seq = (self.aas_seq + 1) & 0xffff
              
              self.timer = threading.Timer(self.INTERVAL, self.send)
              self.timer.start()
    filename: '"SLABCD$$010000.png"'
    lot_id: '666'
    port: '0x1001'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '2048'
    forward: 'False'
    shift: 'True'
    type: complex
    window: window.rectangular(2048)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '80000'
    decim: '1'
    gain: '0.1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '20000'
    win: window.WIN_HAMMING
  states: {}
- name: nrsc5_hdc_encoder_0
  id: nrsc5_hdc_encoder
  parameters:
    bitrate: '64000'
    channels: '2'
  states: {}
- name: nrsc5_l1_fm_encoder_mp1_0
  id: nrsc5_l1_fm_encoder_mp1
  parameters: {}
  states: {}
- name: nrsc5_l2_encoder_0
  id: nrsc5_l2_encoder
  parameters:
    data_bytes: '2000'
    first_prog: '0'
    num_progs: '1'
    size: '146176'
  states: {}
- name: nrsc5_psd_encoder_0
  id: nrsc5_psd_encoder
  parameters:
    artist: Artist
    prog_num: '0'
    title: Title
  states: {}
- name: nrsc5_sis_encoder_0
  id: nrsc5_sis_encoder
  parameters:
    altitude: '93.0'
    country_code: US
    fcc_facility_id: '0'
    latitude: '40.6892'
    longitude: '-74.0445'
    message: Generated by GNU Radio
    mode: nrsc5.pids_mode.FM
    num_programs: '1'
    program0: nrsc5.program_type.NEWS
    program1: nrsc5.program_type.NEWS
    program2: nrsc5.program_type.NEWS
    program3: nrsc5.program_type.NEWS
    program4: nrsc5.program_type.NEWS
    program5: nrsc5.program_type.NEWS
    program6: nrsc5.program_type.NEWS
    program7: nrsc5.program_type.NEWS
    short_name: ABCD-FM
    slogan: This is ABCD-FM
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '21'
    interp: '50'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '21'
    interp: '100'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '49'
    interp: '125'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_2
  id: rational_resampler_xxx
  parameters:
    decim: '243'
    interp: '256'
    taps: ''
    type: ccc
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: freq
    clock_rate: '0.0'
    gain0: '70'
    len_tag_name: ''
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_wfm_tx_0_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_add_xx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_conjugate_cc_0, '0', rational_resampler_xxx_1, '0']
- [blocks_delay_0, '0', analog_wfm_tx_0_0, '0']
- [blocks_keep_m_in_n_0, '0', blocks_multiply_xx_0, '1']
- [blocks_message_strobe_0, strobe, nrsc5_l2_encoder_0, aas]
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_xx_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_repeat_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_vector_source_x_0, '0', blocks_multiply_xx_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_keep_m_in_n_0, '0']
- [blocks_wavfile_source_0, '0', nrsc5_hdc_encoder_0, '0']
- [blocks_wavfile_source_0, '1', nrsc5_hdc_encoder_0, '1']
- [blocks_wavfile_source_1, '0', blocks_delay_0, '0']
- [epy_block_0, aas, nrsc5_l2_encoder_0, aas]
- [fft_vxx_0, '0', blocks_repeat_0, '0']
- [low_pass_filter_0_0, '0', blocks_add_xx_0, '1']
- [nrsc5_hdc_encoder_0, '0', nrsc5_l2_encoder_0, '0']
- [nrsc5_l1_fm_encoder_mp1_0, '0', fft_vxx_0, '0']
- [nrsc5_l2_encoder_0, '0', nrsc5_l1_fm_encoder_mp1_0, '0']
- [nrsc5_psd_encoder_0, '0', nrsc5_l2_encoder_0, '1']
- [nrsc5_sis_encoder_0, '0', nrsc5_l1_fm_encoder_mp1_0, '1']
- [rational_resampler_xxx_0_0, '0', rational_resampler_xxx_0_0_0, '0']
- [rational_resampler_xxx_0_0_0, '0', low_pass_filter_0_0, '0']
- [rational_resampler_xxx_1, '0', rational_resampler_xxx_2, '0']
- [rational_resampler_xxx_2, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0-rc1
